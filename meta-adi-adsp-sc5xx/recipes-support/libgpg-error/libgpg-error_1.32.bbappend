FILESEXTRAPATHS_prepend := "${THISDIR}/libgpg-error:"
SRC_URI += " \
	file://0001-namespace-conflict.patch \
	"
