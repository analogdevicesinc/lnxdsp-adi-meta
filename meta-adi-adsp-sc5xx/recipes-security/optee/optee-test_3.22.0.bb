require optee-test.inc

SRCREV = "a286b57f1721af215ace318d5807e63f40186df6"

COMPATIBLE_MACHINE = "(adsp-sc598-som-ezkit)"
