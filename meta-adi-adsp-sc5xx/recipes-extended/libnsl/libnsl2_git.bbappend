do_install(){
	echo "Nothing to install, provided by toolchain"
}
