FILESEXTRAPATHS_prepend := "${THISDIR}/liburcu:"   

SRC_URI += " \
	file://0001-test_uatomic-currently-fails-to-compile-skip-for-now.patch \
"
