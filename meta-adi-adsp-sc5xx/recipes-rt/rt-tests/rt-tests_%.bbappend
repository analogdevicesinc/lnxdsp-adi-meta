inherit adsp-ptest-cleanup
