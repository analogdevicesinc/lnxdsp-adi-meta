inherit adsp-sc5xx-bootstrap

LICENSE = "MIT"
