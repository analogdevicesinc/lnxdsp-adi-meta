FILESEXTRAPATHS_prepend := "${THISDIR}/gcc:"

SRC_URI += " \
	file://0001-Fixup-invalid-warning-for-ARM-Cortex-A55.patch \
"

