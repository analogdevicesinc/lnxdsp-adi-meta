FILESEXTRAPATHS:prepend := "${THISDIR}/python3:"

SRC_URI += " \
	file://0001-The-NIS-module-does-not-build-properly.-Disabling-fo.patch \
"
