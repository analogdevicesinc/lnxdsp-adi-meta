EXTRA_OEMAKE += " CROSS_COMPILE=${TARGET_PREFIX}"
