RDEPENDS_${PN} += "bash"
RDEPENDS_${PN}-tests += "bash"
