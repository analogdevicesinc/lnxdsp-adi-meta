inherit adsp-sc57x-minimal

SUMMARY = "Minimal image for Analog Devices ADSP-SC57x boards"
LICENSE = "MIT"