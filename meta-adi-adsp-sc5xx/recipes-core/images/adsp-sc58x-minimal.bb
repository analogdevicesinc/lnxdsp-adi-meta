inherit adsp-sc58x-minimal

SUMMARY = "Minimal image for Analog Devices ADSP-SC58x boards"
LICENSE = "MIT"