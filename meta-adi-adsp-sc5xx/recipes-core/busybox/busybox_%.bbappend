FILESEXTRAPATHS:prepend := "${THISDIR}/busybox:"

SRC_URI += " \
	file://defconfig \
	file://tiny.cfg \
"
