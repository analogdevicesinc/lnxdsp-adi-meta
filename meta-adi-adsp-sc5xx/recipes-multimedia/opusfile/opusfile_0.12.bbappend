SRC_URI = "https://ftp.osuosl.org/pub/xiph/releases/opus/${BP}.tar.gz"
