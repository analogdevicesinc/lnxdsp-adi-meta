FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-add-adi-sc5xx-alsa-state.patch \
"
