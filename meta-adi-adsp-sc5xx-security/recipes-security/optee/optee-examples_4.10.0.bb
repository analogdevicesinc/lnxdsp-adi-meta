require optee-examples.inc

SRCREV = "934c7edb74a26e90f68024cf441073528444177f"

COMPATIBLE_MACHINE = "adsp-sc598-som-ezkit"
