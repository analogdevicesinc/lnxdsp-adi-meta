require optee-examples.inc

SRCREV = "378dc0db2d5dd279f58a3b6cb3f78ffd6b165035"

COMPATIBLE_MACHINE = "adsp-sc598-som-ezkit"
