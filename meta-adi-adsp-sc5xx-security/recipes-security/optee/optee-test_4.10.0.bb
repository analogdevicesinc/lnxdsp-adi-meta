require optee-test.inc

SRCREV = "88c93e87a5c172363ee986ded036a25cafcc9d2c"

COMPATIBLE_MACHINE = "(adsp-sc598-som-ezkit)"
