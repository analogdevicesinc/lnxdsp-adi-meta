require u-boot-adi.inc

PR = "r0"

BRANCH = "u-boot-2015..."

SRCREV = "..."

